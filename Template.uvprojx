# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\led;.\Public;.\APP\beep;.\APP\key;.\APP\exti;.\APP\time;.\APP\pwm;.\APP\iwdg;.\APP\wwdg;.\APP\input;.\APP\touch_key;.\APP\rng;.\APP\wkup;.\APP\adc;.\APP\adc_temp;.\APP\dac;.\APP\pwm_dac;.\APP\dma;.\APP\rtc;.\APP\24Cxx;.\APP\iic;.\APP\ds18b20;.\APP\hwjs;.\APP\rs485;.\APP\can;.\APP\tftlcd;.\APP\flash;.\APP\spi;.\APP\stm32_flash;.\APP\mpu6050;.\APP\mpu6050\eMPL;.\APP\sram;.\APP\OLED;.\Coder\CRC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_rng.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_dac.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_can.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_flash.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Public
    ./Public/: system.c SysTick.c usart.c
  group APP
    ./APP/led/: led.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/key/: key.c
    ./APP/sram/: sram.c
    ./APP/OLED/: OLED.c OLED.h
    ./APP/exti/: exti.c
  group Coder
    ./Coder/CRC/: crc.c
